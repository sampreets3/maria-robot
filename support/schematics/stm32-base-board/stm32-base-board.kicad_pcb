# Repository sampreets3/maria-robot

File README.md:

# maria-robot

MARIA is a simple robot which will help me understand how to design the systems of a complex robot. Features will be mentioned as they are added.
The organization of the project is divided into three main components: The ROS workspace, the necessary resources *(books, papers, etc.)* and any supporting material. This may include a lot of things such as the electrical schematics and board layouts for several boards, the CAD models, the PCB fabrication files, and so on.

---

## Roadmap

As this is mainly a summer project, my current aim is to get all the electronics and hardware done. That way, I can get a basic idea about how the system would look and likely behave. Writing software and firmware would then be easier. A good approach in my opinion is to keep the ROS based processing separate from the low-level actions, and write a bridge between the two when necessary. The microcontroller I have decided to go with for designing the base board is the STM32F103C8T6 from ST Microelectronics. This is a small ARM Cortex M3 based microcontroller, packed with a lot of features. The design of the base board is highly inspired by the famous "Blue Pill" line of cheap development boards featuring this MCU. For the moment, the number of sensors are being kept simple - IR sensors as limit switches, to always keep the robot at a certain distance from the walls. There will be two IR sensors on each face, so 8 in total.

After having finished with the hardware and designs, I will focus on writing the low-level microcontroller code to interact with the sensors. I will be using bare-metal programming, although if things get too complex, I might try to compile everything within a C/C++ library. When writing the code, the first test would be to see if I can get data out of the IR sensors. Once that is done, I will focus on the SPI communication channel, to write the driver code for the motor controllers. The logic is pretty simple, so I think I might be able to provide API based framework for it.

With the electronics design done and the low level drivers tested, I will then focus on creating the simple ROS workspace for the high-level interaction with the robot. While I send the board designs for fabrication, I will start by using the ros_bridge package to see if I can establish communication between the PC and the MCU or not. I am thinking of using a Raspberry Pi at the moment, but it might change if I come across a better SBC.

Then onwards, most of the development will focus on the ROS side of things, like using a vision system, introducing some simple AI into it, etc. I will revisit the electronics designs only if I feel the need of extra sensors, or something goes wrong.

---

## Updates

**Added three ROS packages to the main catkin workspace.** There are three main packages as of now: [maria_robot_control](https://github.com/sampreets3/maria-robot/tree/master/maria_ros_ws/src/maria_robot_control), which will focus on the control of the differential drive robot, [maria_robot_gazebo](https://github.com/sampreets3/maria-robot/tree/master/maria_ros_ws/src/maria_robot_gazebo)
where all the files required for the Gazebo simulation will reside, and [maria_robot_description](https://github.com/sampreets3/maria-robot/tree/master/maria_ros_ws/src/maria_robot_description) which will host all the CAD files for the chassis design and the corresponding URDF imports.

**Updated the Motor Controller Schematic.** Refined the design a little bit. The AMS1117 LDOs use the copper plane as a heatsink, as was pointed out by [Mr. Petr Dvořák](https://www.linkedin.com/in/petr-dvorak-hw/). Thus, I created two copper planes, one for 3.3V and another for 5V, for the heat to dissipate. Also, I had overlooked the use of decoupling capacitors in the design. Added them close to the ICs.

**Added schematics for STM32 base board.** This board is going to be responsible for processing sensor data, sending commands to the motor controller, and in later stages, communicating with the SBC running ROS. Need to finish the layout of the board.

**Added the legacy files and libraries for the original MARIA design.** MARIA was originally developed during my time at The Neotia University, India. Added the old files and libraries for reference or if someone from the old team would need support. The old architecture was based off an Arduino Uno, so you will mainly find Arduino codes, a MARIA library containing essential functionalities.

**Added the main ROS workspace for the robot.** Configured it with a simple chatter application under a package named "comm". Currently hosts two executables, "talker" and "listener". Maybe I will add the build directories to .gitignore

<!-- BADGES FOR UPDATE STATUS-->
<!-- Used to indicate what kind of work was updated-->
<!-- The general rule of thumb is to make it understandable. So, we can use any sort of indicator of what it was. -->
<!-- For instance, I had updated the schematics in the support section, so I added the badge as "schematic - support" -->
<!-- You can make your badge from this generic badge tag :  -->
<!-- Just change the <SUBJECT>, <STATUS>, and <COLOR> fields to appropriate values -->
<!-- Ideally, use blue for electrical schematics/layout, red for code updates, and other colors as per need -->

---

## Usage

If you are interested in contributing to this project, be my guest!
  1. You can start by forking the repo using `git clone https://github.com/sampreets3/maria-robot.git`, and begin working on things.
  1. You can open an issue pertaining to any fix/features that you might want to implement.
  1. If everything looks good, then open a PR and we shall merge the commit.

---

## Contact

You can reach out to me via email at : `sampreets3@gmail.com`

## KiCad design support/schematics/stm32-base-board/stm32-base-board.kicad_pcb

Parts:
C1, C2, C4, C6, C7, C13: 10nF; CP_EIA-1608-08_AVX-J
C3, C10, C11: 22pF; CP_EIA-1608-08_AVX-J
C5: 10uF; CP_EIA-1608-08_AVX-J
C8, C9, C14: 1uF; CP_EIA-1608-08_AVX-J
C12: 0.1uF; CP_EIA-1608-08_AVX-J
D1: D_Schottky_Small; D_1206_3216Metric
D2: red; LED_1206_3216Metric
D3: green; LED_1206_3216Metric
FB1, FB2: 100@100MHz; R_0805_2012Metric
J1: USB_B_Mini; USB_Mini-B_Lumberg_2486_01_Horizontal
J2: Boot_Pins; PinHeader_2x03_P2.54mm_Vertical
J3: SWDebugger; PinHeader_1x04_P2.54mm_Horizontal
J4: Power; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J5: SPI_Connector; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
J6: IR1; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J7: IR2; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J8: IR3; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
R1: 10K; R_0805_2012Metric
R2, R6: 100K; R_0805_2012Metric
R3, R4, R9, R10, R11, R12: 20; R_0805_2012Metric
R5: 4k7; R_0805_2012Metric
R7, R8: 220; R_0805_2012Metric
SW1: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3VA: C13.1, C14.1, FB2.1, U2.9 (VDDA)
+3V3: C1.1, C2.1, C4.1, C6.1, C7.1, C8.1, C9.1, C12.1, D2.2 (A), FB2.2, J2.1, J2.4, J3.4, J6.3, J7.3, J8.3, R1.2, U1.2 (VO), U2.1 (VBAT), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD)
+5V: D1.2 (A), J1.1 (VBUS), J4.2, R5.2
BOOT0: R2.2, U2.44 (BOOT0)
BOOT1: R6.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.4 (ID), J1.5 (GND), J2.3, J2.6, J3.1, J4.1, J6.1, J7.1, J8.1, R7.1, R8.1, SW1.1, U1.1 (GND), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS)
IR1: J6.2
IR2: J7.2
IR3: J8.2
MISO: R10.1; also elsewhere on the board
MOSI: R11.1; also elsewhere on the board
NCS: R9.1
NRST: C3.1, R1.1, SW1.2, U2.7 (NRST)
unnamed: C5.1, FB1.1, U1.3 (VI)
unnamed: D1.1 (K), FB1.2
unnamed: D2.1 (K), R7.2
unnamed: D3.1 (K), R8.2
unnamed: J1.2 (D-), R4.2
unnamed: J1.3 (D+), R3.2
unnamed: J2.2, R2.1
unnamed: J2.5, R6.2
unnamed: J5.1, R12.2
unnamed: J5.2, R11.2
unnamed: J5.3, R10.2
unnamed: J5.4, R9.2
OSC_IN: C11.1, U2.5 (PD0), Y1.2
OSC_OUT: C10.1, U2.6 (PD1), Y1.1
PA0: U2.10 (PA0)
PA1: U2.11 (PA1)
PA2: U2.12 (PA2)
PA3: U2.13 (PA3)
PA4: U2.14 (PA4)
PA5: U2.15 (PA5)
PA6: U2.16 (PA6)
PA7: U2.17 (PA7)
PA8: U2.29 (PA8)
PA9: U2.30 (PA9)
PA10: U2.31 (PA10)
PA15: U2.38 (PA15)
PB0: U2.18 (PB0)
PB1: U2.19 (PB1)
PB2: U2.20 (PB2)
PB3: U2.39 (PB3)
PB4: U2.40 (PB4)
PB5: U2.41 (PB5)
PB6: U2.42 (PB6)
PB7: U2.43 (PB7)
PB8: U2.45 (PB8)
PB9: U2.46 (PB9)
PB10: U2.21 (PB10)
PB11: U2.22 (PB11)
PB12: U2.25 (PB12)
PB13: U2.26 (PB13)
PB14: U2.27 (PB14)
PB15: U2.28 (PB15)
PC13: D3.2 (A), U2.2 (PC13)
PC14: U2.3 (PC14)
PC15: U2.4 (PC15)
SCK: R12.1; also elsewhere on the board
SWDIO: J3.3, U2.34 (PA13)
USB_D+: R3.1, R5.1, U2.33 (PA12)
USB_D-: R4.1, U2.32 (PA11)

Notes on the sheet:
NOTE: Use all tantalum capacitors here
ANALOG VOLTAGE FILTERING
For SPI communication with other devices
For attaching a digital IR sensor
EXTERNAL RESET CIRCUITRY
EXTERNAL OSCILLATOR
STATUS LEDS
VOLTAGE REGULATION
BOOTLOADER SELECT
DECOUPLING CAPACITORS
MICROCONTROLLER
For external power input
CONNECTORS
TODO: 1/ Add MPU6050 sensor(check for SPI comm) 2/ Add data logging capability 3/ Maybe need more sensors
Note: All resistors for SPI are 33R
ROBOT BASE BOARD

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
Board: 2 copper layers, 52.2 x 52.2 mm, 48 parts (0 on the bottom side), 32 nets.

Other parts of the board:
J9: SPI_Connector; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
R13, R14, R15, R16: 20; R_0805_2012Metric

Their connections:
MISO: R14.1; also elsewhere on the board
MOSI: R15.1; also elsewhere on the board
unnamed: J9.1, R16.2
unnamed: J9.2, R15.2
unnamed: J9.3, R14.2
unnamed: J9.4, R13.2
SCK: R16.1; also elsewhere on the board

## KiCad design support/schematics/motor-controller/motor-control-spi.kicad_pcb

Board: 2 copper layers, 69.9 x 40.8 mm, 29 parts (0 on the bottom side), 30 nets.

Parts:
C1, C3: 10uF; C_0805_2012Metric
C2, C4: 1uF; C_0805_2012Metric
C5, C6, C7, C8: 100uF; C_0805_2012Metric
C9: 10nF; C_0805_2012Metric
D1: green; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Motor2; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
J2: PWR; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J3: Motor1; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
J4: SPI; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
R1: 330R; R_0805_2012Metric
R2: 100K; R_0805_2012Metric
R3, R4, R5, R6: 33R; R_0805_2012Metric
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3, U4: L293D; DIP-16_W7.62mm
U5: MCP23S08-xP; DIP-18_W7.62mm

Connections:
+3V3: C4.1, C9.1, D1.2, R2.1, U2.2, U5.18
+5V: C2.1, C3.1, U1.2, U2.3, U3.1, U3.9, U4.1, U4.9
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J2.2, R1.2, U1.1, U2.1, U3.4, U3.5, U3.12, U3.13, U4.4, U4.5, U4.12, U4.13, U5.4, U5.5, U5.9
GP0: U3.2, U5.10
GP1: U3.7, U5.11
GP2: U3.10, U5.12
GP3: U3.15, U5.13
GP4: U4.2, U5.14
GP5: U4.7, U5.15
GP6: U4.10, U5.16
GP7: U4.15, U5.17
M1A: J3.1, U3.3
M1B: J3.2, U3.6
M1C: J3.3, U3.11
M1D: J3.4, U3.14
M2A: J1.1, U4.3
M2B: J1.2, U4.6
M2C: J1.3, U4.11
M2D: J1.4, U4.14
MISO: J4.2, R6.2
MOSI: J4.3, R5.2
NCS: J4.1, R3.2
NRST: R2.2, U5.6
unnamed: D1.1, R1.1
unnamed: R3.1, U5.7
unnamed: R4.1, U5.1
unnamed: R5.1, U5.2
unnamed: R6.1, U5.3
SCK: J4.4, R4.2
VCC: C1.1, C5.1, C6.1, C7.1, C8.1, J2.1, U1.3, U3.8, U3.16, U4.8, U4.16

## KiCad design support/schematics/motor-controller/motor-controller.kicad_pcb

Board: 2 copper layers, 62.7 x 38.4 mm, 15 parts (0 on the bottom side), 25 nets.

Parts:
C1: 22uF; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
D1: LED_Small; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Power_Connector; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J2: SPI_Connector; JST_EH_S6B-EH_1x06_P2.50mm_Horizontal
J3, J4: Motor_Connector; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
R1: 330; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: MCP23S08-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U3, U4: L293D; DIP-16_W7.62mm

Connections:
+3V3: J2.1, U2.6, U2.18
+5V: C1.1, D1.2, U1.2, U3.1, U3.9, U4.1, U4.9
CS: J2.5, U2.7
GND: C1.2, J1.2, J2.6, R1.2, U1.1, U2.4, U2.5, U2.9, U3.4, U3.5, U3.12, U3.13, U4.4, U4.5, U4.12, U4.13
GP0: U2.10, U3.2
GP1: U2.11, U3.7
GP2: U2.12, U3.10
GP3: U2.13, U3.15
GP4: U2.14, U4.2
GP5: U2.15, U4.7
GP6: U2.16, U4.10
GP7: U2.17, U4.15
M1A: J3.1, U3.3
M1B: J3.2, U3.6
M1C: J3.3, U3.11
M1D: J3.4, U3.14
M2A: J4.1, U4.3
M2B: J4.2, U4.6
M2C: J4.3, U4.11
M2D: J4.4, U4.14
MISO: J2.4, U2.3
MOSI: J2.3, U2.2
unnamed: D1.1, R1.1
SCK: J2.2, U2.1
VCC: J1.1, U1.3, U3.8, U3.16, U4.8, U4.16

## Commit log

2020-07-23 updated the schematic
2020-07-29 Designs for a motor control board
    Included layout and schematics for an SPI based bipolar stepper motor controller board using the MCP23S08 and L293Ds.
2020-07-30 Updated README.md
    Updated the landing README file, and added Gerber fabrication outputs for the motor controller
2020-07-30 Deleted unwanted files
    KiCAD creates backups for each file, deleted them in this commit
2020-07-30 Changed the main board schematic
    - Added analog voltage filtering
    - Added JST connector for external 5V power
2020-08-16 Updated Motor Driver Schematics
2020-08-16 Uploaded the schematic design for STM32 base board
2020-08-16 Added the resources directory
2020-08-16 Added hits counter in README
2020-08-16 Added supporting files/libraries for the old MARIA design
2020-08-19 Added the ros workspace for development
2020-08-19 added libraries for SPI and GPIO
2020-08-20 Updated README.md and changed design a little bit
2020-10-03 Created ros workspace
2020-10-03 Added the maria_robot_gazebo package for Gazebo simulations
2020-10-04 Removed unnecessary Gazebo files
2020-10-07 Added the control package
2020-11-06 Deleted the build devel and logs directories
2020-11-06 Added ROS packages

Notices in the files:
README.md:
License: GPL v3
